Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: SD-RHYT-IG-REC-model.ifc
Time: 2026-09-03T23:23:38+00:00
Author: OOO PKF ORION, zavod-orion.ru
Organization: OOO PKF ORION, zavod-orion.ru
Written by: AutoCAD 2024
Made in: AutoCAD 2024
Authorization: OOO PKF ORION, zavod-orion.ru

# IfcBuildingElementProxy, SD-RHYT-IG-REC Оборудование МГН «Музыкальный инструмент «Ритм»»
In: Площадка
Pset_ManufacturerTypeInformation - Manufacturer: ООО «ПКФ «ОРИОН» · zavod-orion.ru · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: SD-RHYT-IG-REC; ModelReference: Оборудование МГН «Музыкальный инструмент «Ритм»»; ProductionYear: 2026
